# Keil uVision project 01_HeartMonitor_Register.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCompiler_506_b960)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: 01_LED_Register +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c include: .\Start;.\User;.\Driver\USART;.\Driver\ADC;.\Driver\Timer;.\Common\Debug;.\Application\Communication;.\Application\Sampling
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Start
    ./Start/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s
  group User
    ./User/: main.c
  group Common
    ./Common/Debug/: Common_Debug.c
  group Driver
    ./Driver/USART/: Driver_USART1.c
    ./Driver/ADC/: Driver_ADC1.c
    ./Driver/Timer/: Driver_TIM7.c
  group Application
    ./Application/Communication/: App_Comm.c
    ./Application/Sampling/: App_Sampling.c
